DATA SEGMENT
    NUM1 DW 1234H, 5678H
    NUM2 DW 9ABC, DEF0H
    RESULT DW 0, 0
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE, DS:DATA

START:
    MOV AX, DATA
    MOV DS, AX

    MOV AX, NUM1
    MOV BX, NUM1+2

    MOV DX, NUM2
    MOV DI, NUM2+2

    MOV AX, NUM1
    MUL DX
    MOV RESULT

    MOV AX, BX
    MUL DI
    ADD RESULT+2, AX

    MOV AX, NUM1
    MOV BX, NUM2+2
    MUL BX
    ADD RESULT+2, AX

    MOV AX, NUM1+2
    MOV DX, NUM2
    MUL DX
    ADD RESULT+2, AX

    MOV AH, 4Ch
    INT 21h

CODE ENDS
END START